# Keil uVision project minimal.uvprojx, settings and files
target Debug (ARM-ADS)
  device: STM32F407VGTx STMicroelectronics
  c define: DEBUG,STM32F407xx
  c include: ./Inc;./Drivers/CMSIS/Include
