# Keil uVision project cubeMX-target-groups.uvprojx, settings and files
target FOC-stm32g0 (ARM-ADS)
  device: STM32G070CBTx STMicroelectronics
  c define: STM32G070xx,USE_HAL_DRIVER
  c include: ../Core/Inc;../Bsp
  group Application
    ./: startup_stm32g070xx.s
    ../Core/Src/: main.c
  group Bsp
    ../Bsp/bsp_adc/: bsp_adc.c
