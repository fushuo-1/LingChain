# Keil uVision project sample.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: STM32G071RBTx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.3.0.0
  cpu: IRAM(0x20000000,0x00009000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M0+") FPU0
  output: Target 1 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32G071xx
  c misc: -I./Drivers/CMSIS/Include
  c include: ./Core/Inc;./Drivers/STM32G0xx_HAL_Driver/Inc;./Drivers/CMSIS/Device/ST/STM32G0xx/Include
target Target 2 (ARM-ADS)
  device: STM32F103C8Tx STMicroelectronics
  c define: USE_STDPERIPH_DRIVER
  c include: ./Inc
